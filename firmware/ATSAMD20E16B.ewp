# IAR project ATSAMD20E16B.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20E16B Microchip ATSAMD20E16B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __SAMD20E16B__; F_CPU=48000000
  ICCARM.CCIncludePath2: ; config; examples; hal\include; hal\utils\include; hpl\core; hpl\eic; hpl\gclk; hpl\pm; hpl\port; hpl\sysctrl; hri; ; CMSIS\Core\Include; samd20b\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMD20E16B__
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: ATSAMD20E16B.out
  ILINK.IlinkIcfFile: samd20b\iar\iar\samd20e16b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; __SAMD20E16B__; F_CPU=48000000
  ICCARM.CCOptLevel: 3
  group (top)
    ./: iar-project-connection.ipcf
  group src
    ./: atmel_start.c atmel_start.h atmel_start_pins.h driver_init.c driver_init.h main.c
  group src/CMSIS/Core/Include
    CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group src/config
    config/: hpl_eic_config.h hpl_gclk_config.h hpl_pm_config.h hpl_sysctrl_config.h peripheral_clk_config.h
  group src/examples
    examples/: driver_examples.c driver_examples.h
  group src/hal/include
    hal/include/: hal_atomic.h hal_delay.h hal_ext_irq.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hpl_core.h hpl_delay.h hpl_ext_irq.h hpl_gpio.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_reset.h hpl_sleep.h
  group src/hal/src
    hal/src/: hal_atomic.c hal_delay.c hal_ext_irq.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c
  group src/hal/utils/include
    hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_list.h
  group src/hal/utils/src
    hal/utils/src/: utils_assert.c utils_event.c utils_list.c
  group src/hpl/core
    hpl/core/: hpl_core_m0plus_base.c hpl_core_port.h hpl_init.c
  group src/hpl/eic
    hpl/eic/: hpl_eic.c
  group src/hpl/gclk
    hpl/gclk/: hpl_gclk.c hpl_gclk_base.h
  group src/hpl/pm
    hpl/pm/: hpl_pm.c hpl_pm_base.h
  group src/hpl/port
    hpl/port/: hpl_gpio_base.h
  group src/hpl/sysctrl
    hpl/sysctrl/: hpl_sysctrl.c
  group src/hri
    hri/: hri_ac_d20.h hri_adc_d20.h hri_d20.h hri_dac_d20.h hri_dsu_d20.h hri_eic_d20.h hri_evsys_d20.h hri_gclk_d20.h hri_nvic_d20.h hri_nvmctrl_d20.h hri_pac_d20.h hri_pm_d20.h hri_port_d20.h hri_rtc_d20.h hri_sercom_d20.h hri_sysctrl_d20.h hri_systemcontrol_d20.h hri_systick_d20.h hri_tc_d20.h hri_wdt_d20.h
  group src/samd20b/iar
    samd20b/iar/: system_samd20.c
  group src/samd20b/iar/iar
    samd20b/iar/iar/: startup_samd20.c
  group src/samd20b/include
    samd20b/include/: component-version.h sam.h samd20.h samd20e14b.h samd20e15b.h samd20e15bu.h samd20e16b.h samd20e16bu.h samd20g14b.h samd20g15b.h samd20g16b.h samd20j14b.h samd20j15b.h samd20j16b.h system_samd20.h
  group src/samd20b/include/component
    samd20b/include/component/: ac.h adc.h dac.h dsu.h eic.h evsys.h gclk.h nvmctrl.h pac.h pm.h port.h rtc.h sercom.h sysctrl.h tc.h wdt.h
  group src/samd20b/include/instance
    samd20b/include/instance/: ac.h adc.h dac.h dsu.h eic.h evsys.h gclk.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h ptc.h rtc.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sysctrl.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h wdt.h
  group src/samd20b/include/pio
    samd20b/include/pio/: samd20e14b.h samd20e15b.h samd20e15bu.h samd20e16b.h samd20e16bu.h samd20g14b.h samd20g15b.h samd20g16b.h samd20j14b.h samd20j15b.h samd20j16b.h
